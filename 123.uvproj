# Keil uVision project 123.uvproj, settings and files
target SH79F169B V1.1 (MCS-51)
  device: SH79F169B Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0xFFFF) XRAM(0-0xAFF) CLOCK(8192000)
  output: 123
  c flags: Optimize=3 SizeSpeed=1
  c include: .\Head
  group App
    ./App/: AdjustMeterProc.c BCDAndHEXSub.c BCDCalSub.c Delay.c DisplayProc.c EEprom.c MeasureProc.c PowerAdjustMeter.c RTCEventThreadProc.c Commu.c
  group Main
    ./App/: Main.c
  group Driver
    ./Drive/: LCDDriver.c NBDriver.c RELAYDrive.c RTCDriver.c UARTDriver.c IICDriver.C
  group MCU
    ./MCU/: 642B_EMU.c 642B_INT.c 642B_MCU.c
